# Keil uVision project Imu.uvprojx, settings and files
target Imu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Imu
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;             ../Drivers/CMSIS/Include;             .\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_can.h
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c spi.c gpio.c
    ../../Remote_can_merged/Remote_can_merged/RemoteControl/Src/: usart.c tim.c dma.c
    ../../Remote_can_merged/Remote_can_merged/RemoteControl/Inc/: tim.h usart.h dma.h
    ../../Remote_can_merged/Remote_can_merged/RemoteControl/MDK-ARM/: can.c define.h can.h
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/UserBsp
    ./bsp/: bsp_imu.c bsp_uart.c bsp_uart.h
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
